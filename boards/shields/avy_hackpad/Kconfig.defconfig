## boards/shields/avy_hackpad/Kconfig.defconfig
```kconfig
if SHIELD_AVY_HACKPAD

config ZMK_KEYBOARD_NAME
    default "Avy's Hackpad"

endif # SHIELD_AVY_HACKPAD
```
